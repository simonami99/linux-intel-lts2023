## drivers/platform/x86/socwatch/Kconfig
```kconfig
menuconfig INTEL_SOCWATCH
	depends on X86 || X86_64
	tristate "SocWatch Driver Support"
	help
	  Say Y here to enable SocWatch driver
```
